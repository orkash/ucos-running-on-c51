# Keil uVision project ucos_runing_on_c51.uvproj, settings and files
target uCOS (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: ucos_runing_on_c51 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Source
  group source related to CPU
    ./: STARTUP.A51
    ./Source/: OS_CPU_A.asm OS_CPU_C.c
  group source self-contained
    ./Source/: os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.c
